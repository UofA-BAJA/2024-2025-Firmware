# Repository UofA-BAJA/2024-2025-Firmware

File README.md:

# 2024-2025-Firmware

The software behind the electrical system in Baja Wildcat Racing.

This is the BAJA Wildcat Racing team for school year 2024-2025.

Check out the 'doc' (documentation) folder in order to get started!

Electrical Lead: Dylan Correa

Webmaster/Software Lead: Matthew Larson

## KiCad design hardware/KICAD Projects/BAJE SAE 2024/CAN Integration/CAN Integration.kicad_pcb

Board: 2 copper layers, 27.7 x 40.2 mm, 16 parts (0 on the bottom side), 16 nets.

Parts:
C1: 10uF/16V; tantalum A
C2, C5: 100nF; C0603
C3, C4: 22pF; C0603
P1: Header 7; HDR1X7
P2, P3: Header 2; HDR1X2
P4: Terminal Block 3.5mmPitch: 3,5 mmNumber of pins: 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; TERMINAL-BLOCK-2-PIN-3.5MM-ROUND-PAD
POW: RED LED; CHIPLED_0603
R1: 1kΩ; R0603
R2: 120Ω; R0603
R3: 10kΩ; R0603
U1: TJA1050DRG; SOIC-8E
U2: MCP2515-I; SOIC-18_L11.6-W7.5-P1.27-LS10.3-BL
X1: 8MHz; HC-49US_L11.5-W4.5-P4.88

Connections:
GND: C1.2, C2.1, C3.2, C4.2, C5.1, P1.6, POW.C, U1.2, U1.8, U2.9
NetC3_1: C3.1, U2.7, X1.2
NetC4_1: C4.1, U2.8, X1.1
NetP1_1: P1.1, U2.12
NetP1_2: P1.2, U2.13
NetP1_3: P1.3, U2.14
NetP1_4: P1.4, U2.15
NetP1_5: P1.5, U2.16
NetP2_1: P2.1, P4.2, R2.1, U1.7
NetP2_2: P2.2, P3.1, P4.1, U1.6
NetP3_2: P3.2, R2.2
NetPOW_A: POW.A, R1.2
NetR3_1: R3.1, U2.17
NetU1_1: U1.1, U2.1
NetU1_4: U1.4, U2.2
VCC: C1.1, C2.2, C5.2, P1.7, R1.1, R3.2, U1.3, U2.18

## KiCad design hardware/KICAD Projects/BAJA SAE 2025/SMD Temperature Sensor/CAN Integration.kicad_pcb

Board: 2 copper layers, 15 parts (0 on the bottom side), 17 nets.

Parts:
C1: 10uF/16V; tantalum A
C2, C5: 100nF; C0603
C3, C4: 22pF; C0603
J2: CAN to outer connector; SolderWire-0.1sqmm_1x04_P3.6mm_D0.4mm_OD1mm
J5: Conn_01x02; SolderWire-0.75sqmm_1x02_P4.8mm_D1.25mm_OD2.3mm
POW: RED LED; CHIPLED_0603
R1: 1kΩ; R0603
R3: 10kΩ; R0603
U1: TJA1050DRG; SOIC-8E
U2: MCP2515-I; SOIC-18_L11.6-W7.5-P1.27-LS10.3-BL
U3: MLX90614
UNIT_1: ARDUINO_NANO; SHIELD_ARDUINO_NANO
X1: 8MHz; HC-49US_L11.5-W4.5-P4.88

Connections:
+3V: U3.3 (VDD), UNIT_1.17 (3V3)
+5V: J5.1, UNIT_1.27 (+5V)
CS: U2.16 (~CS), UNIT_1.13 (D10)
GND: C1.2, C2.1, C3.2, C4.2, C5.1, J5.2, POW.C, U1.2 (GND), U1.8 (STB), U2.9 (VSS), U3.4 (VSS), UNIT_1.4 (COM/GND), UNIT_1.29 (COM/GND)
High: J2.2, J2.4, U1.7 (CANH)
Low: J2.1, J2.3, U1.6 (CANL)
unnamed: U1.4 (RXD), U2.2 (RXCAN)
unnamed: U1.1 (TXD), U2.1 (TXCAN)
unnamed: C4.1, U2.8 (OSC1)
unnamed: C3.1, U2.7 (OSC2)
unnamed: R3.1, U2.17 (~RESET)
SCK: U2.13 (SCK), UNIT_1.16 (D13/SCK)
SCL: U3.1 (SCL/Vz), UNIT_1.24 (A5)
SDA: U3.2 (SDA/PWM), UNIT_1.23 (A4)
SI: U2.14 (SI), UNIT_1.14 (D11/MOSI)
SO: U2.15 (SO), UNIT_1.15 (D12/MISO)
VCC: C1.1, C2.2, C5.2, R1.1, R3.2, U1.3 (VCC), U2.18 (VDD)

## KiCad design hardware/KICAD Projects/BAJE SAE 2024/12 to 5 with Trimmer/12 to 5 with Trimmer.kicad_pcb

Parts:
J1: Conn_01x04; TerminalBlock_Phoenix_MKDS-3-4-5.08_1x04_P5.08mm_Horizontal
RV1: 3.3k; Potentiometer_Bourns_3296W_Vertical
U1: SKM10E-03

Connections:
unnamed: RV1.1, U1.4 (Trim)
V-: J1.2, U1.2 (GND)
VIN: J1.1, U1.1 (Vin)
VOUT: J1.4, U1.3 (Vout)
VOUT-: J1.3, RV1.2, U1.5 (-Vout)

Notes on the sheet:
= 3.95k
2.5 x 2.32 X(2.43 + 0) RV1= (5.5-5) X 2.32 - 8.2

Board: 2 copper layers, 64.8 x 53.0 mm, 3 parts (0 on the bottom side), 5 nets.

## KiCad design hardware/KICAD Projects/BAJE SAE 2024/Dash/Dash Indicators (Left)/Dash Indicators (Left).kicad_pcb

Parts:
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16: LED; LED_D5.0mm
J1-A1, J1-B1: Conn_01x05; PinHeader_1x05_P2.54mm_Vertical

Connections:
A8: D1.2 (A), D2.2 (A), J1-A1.1
A9: D3.2 (A), D4.2 (A), J1-A1.2
A10: D5.2 (A), D6.2 (A), J1-A1.3
A11: D7.2 (A), D8.2 (A), J1-A1.4
A12: D9.2 (A), D10.2 (A), J1-A1.5
A13: D11.2 (A), D12.2 (A), J1-B1.1
A14: D13.2 (A), D14.2 (A), J1-B1.2
A15: D15.2 (A), D16.2 (A), J1-B1.3
C0: D1.1 (K), D3.1 (K), D5.1 (K), D7.1 (K), D9.1 (K), D11.1 (K), D13.1 (K), D15.1 (K), J1-B1.4
C1: D2.1 (K), D4.1 (K), D6.1 (K), D8.1 (K), D10.1 (K), D12.1 (K), D14.1 (K), D16.1 (K), J1-B1.5

Notes on the sheet:
I/O
LEDs

Board: 2 copper layers, 55.8 x 87.0 mm, 18 parts (2 on the bottom side), 10 nets.

## KiCad design hardware/KICAD Projects/BAJE SAE/Pit Radio/Pit Radio.kicad_pcb

Parts:
J1: Conn_01x02; SolderWire-0.75sqmm_1x02_P4.8mm_D1.25mm_OD2.3mm
U2: E01-ML01DP5; Ebyte E01-ML01DP5
UNIT_1: ESP32-DEVKITC-32D; MODULE_ESP32-DEVKITC-32D; PARTREV V4

Connections:
3V3: U2.2 (VCC), UNIT_1.J2-1 (3V3)
+5V: J1.1, UNIT_1.J2-19 (EXT_5V)
CE: U2.3 (CE), UNIT_1.J3-10 (IO5)
CSN: U2.4 (CSN), UNIT_1.J3-12 (IO16)
GND: J1.2, U2.1 (GND), UNIT_1.J2-14 (GND1), UNIT_1.J3-1 (GND3), UNIT_1.J3-7 (GND2)
SCK: U2.5 (SCK), UNIT_1.J3-9 (IO18)
SI: U2.6 (MOSI), UNIT_1.J3-2 (IO23)
SO: U2.7 (MISO), UNIT_1.J3-8 (IO19)

Notes on the sheet:
ESP32
Radio

Board: 2 copper layers, 55.5 x 65.5 mm, 3 parts (0 on the bottom side), 8 nets.

## KiCad design hardware/KICAD Projects/BAJE SAE/Main Computer/Main Computer.kicad_pcb

Board: 2 copper layers, 55.5 x 65.5 mm, 5 parts (1 on the bottom side), 12 nets.

Parts:
J1: Pi 5 GPIO HEADER; PinHeader_2x20_P2.54mm_Vertical
J3: Conn_01x02; SolderWire-0.75sqmm_1x02_P4.8mm_D1.25mm_OD2.3mm
J4: CAN to outer connector; SolderWire-0.1sqmm_1x04_P3.6mm_D0.4mm_OD1mm
U2: E01-ML01DP5; Ebyte E01-ML01DP5
UNIT_1: HiLetgo CAN Bus; HiLetgo CAN Bus (Facing Up)

Connections:
3V3: J1.1 (3V3), U2.2 (VCC)
+5v: J1.2 (5V), J1.4 (5V), J3.1, UNIT_1.7 (VCC)
CE: J1.15 (GPIO_22), U2.3 (CE)
CS: J1.24 (GPIO_8), UNIT_1.5 (CS)
CSN: J1.26 (GPIO_7), U2.4 (CSN)
GND: J1.6 (GND), J1.9 (GND), J1.14 (GND), J1.20 (GND), J1.25 (GND), J1.30 (GND), J1.34 (GND), J1.39 (GND), J3.2, U2.1 (GND), UNIT_1.6 (GND)
High: J4.2, J4.4, UNIT_1.8 (High_CAN)
INT: J1.22 (GPIO_25), UNIT_1.1 (INT)
Low: J4.1, J4.3, UNIT_1.9 (Low_CAN)
SCK: J1.23 (GPIO_11), U2.5 (SCK), UNIT_1.2 (SCK)
SI: J1.19 (GPIO_10), U2.6 (MOSI), UNIT_1.3 (SI)
SO: J1.21 (GPIO_9), U2.7 (MISO), UNIT_1.4 (SO)

## KiCad design hardware/KICAD Projects/BAJE SAE/Sensor Projects/Speedometer/Speedometer.kicad_pcb

Parts:
C1, C6, C7: 10µ; CP_Radial_D4.0mm_P2.00mm
C2, C3, C4: 10n; C_Disc_D3.8mm_W2.6mm_P2.50mm
C5: 220n; CP_Radial_D6.3mm_P2.50mm
D1: LED; LED_D4.0mm
D2: D; D_DO-41_SOD81_P7.62mm_Horizontal
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
J1: Conn_01x02; SolderWire-0.75sqmm_1x02_P4.8mm_D1.25mm_OD2.3mm
J2: CAN to outer connector; SolderWire-0.1sqmm_1x04_P3.6mm_D0.4mm_OD1mm
R1: 300; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R2, R3, R4, R7, R8: 10k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R5: 22k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R6: 33k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
U1: A3144; PinHeader_1x03_P2.54mm_Vertical
U2: NE555P; DIP-8_W7.62mm
UNIT_1: HiLetgo CAN Bus; Jack_CanBus
UNIT_2: ARDUINO_NANO; Arduino_Nano

Connections:
+5V: C1.1, C2.1, D1.2 (A), J1.1, R2.1, R3.1, R4.1, R5.1, U1.1 (Vcc), U2.4 (R), U2.8 (VCC), UNIT_1.7 (VCC), UNIT_2.27 (+5V), UNIT_2.30 (VIN)
/CV: C4.2, U2.5 (CV)
/DIS_THR: C5.1, R6.2, U2.6 (THR), U2.7 (DIS)
/Diff: C3.2, D2.1 (K), R3.2
/Filter1: C6.1, R7.2, R8.1
/Hall_Out: C3.1, R1.2, R2.2, U1.3 (OUT)
/NE555_Out: R7.1, U2.3 (Q)
/Nano_Input: C7.1, R8.2, UNIT_2.19 (A0)
/Rect: D2.2 (A), R4.2, U2.2 (TR)
CS: UNIT_1.5 (CS), UNIT_2.13 (D10)
GND: C1.2, C2.2, C4.1, C5.2, C6.2, C7.2, J1.2, U1.2 (GND), U2.1 (GND), UNIT_1.6 (GND), UNIT_2.4 (COM/GND), UNIT_2.29 (COM/GND)
High: J2.2, J2.4, UNIT_1.8 (High_CAN)
Low: J2.1, J2.3, UNIT_1.9 (Low_CAN)
unnamed: D1.1 (K), R1.1
unnamed: R5.2, R6.1
SCK: UNIT_1.2 (SCK), UNIT_2.16 (D13/SCK)
SI: UNIT_1.3 (SI), UNIT_2.14 (D11/MOSI)
SO: UNIT_1.4 (SO), UNIT_2.15 (D12/MISO)

Notes on the sheet:
CAN Bus
NE555 Timer; Pulse Generator
Cascading Low-Pass Filters
Nano
Mounting Holes
Hall Effect Sensor; Pullup Resistor
I/O
Differentiator
Rectifier

Board: 2 copper layers, 104.4 x 46.4 mm, 27 parts (1 on the bottom side), 18 nets.

## KiCad design hardware/KICAD Projects/BAJE SAE/Sensor Projects/Tachometer/Tachometerkicad.kicad_pcb

Parts:
C1, C2, C3: 10u; CP_Radial_D5.0mm_P2.50mm
C4: C; C_Disc_D6.0mm_W4.4mm_P5.00mm
D1: D_A-405_P7.62mm_Horizontal
D2: D; D_A-405_P7.62mm_Horizontal
J1, J3: Conn_01x02; SolderWire-0.75sqmm_1x02_P4.8mm_D1.25mm_OD2.3mm
J2: Conn_01x06
J4: CAN to outer connector; SolderWire-0.1sqmm_1x04_P3.6mm_D0.4mm_OD1mm
Q1: NPN; TO-92L_Inline
R1: 10; R_Axial_DIN0411_L9.9mm_D3.6mm_P15.24mm_Horizontal
R2: 470; R_Axial_DIN0411_L9.9mm_D3.6mm_P15.24mm_Horizontal
R3: 1k; R_Axial_DIN0411_L9.9mm_D3.6mm_P15.24mm_Horizontal
R4, R6: 430; R_Axial_DIN0411_L9.9mm_D3.6mm_P15.24mm_Horizontal
R5, R10, R11: 10k; R_Axial_DIN0411_L9.9mm_D3.6mm_P15.24mm_Horizontal
R7: 2k; R_Axial_DIN0411_L9.9mm_D3.6mm_P15.24mm_Horizontal
U1: NE555P; DIP-8_W7.62mm
U2: LM311; DIP-8_W7.62mm
UNIT_1: ARDUINO_NANO; SHIELD_ARDUINO_NANO
UNIT_2: HiLetgo CAN Bus
VR1: 3362P-1-103; TRIM_3362P-1-103; PARTREV 08/26/10

Connections:
555 input: R10.1, U1.2 (TR), U2.7
555 output: R5.1, U1.3 (Q)
+3V: UNIT_1.17 (3V3)
+5V: UNIT_1.27 (+5V), UNIT_2.7 (VCC)
+5v: J3.1, R3.1, R6.2, U1.4 (R), U1.8 (VCC), U2.8 (V+), VR1.1
CS: UNIT_2.5 (CS)
Comparator input: Q1.1 (C), R3.2, U2.2 (+)
GND: C1.2, C2.2, C3.1, C4.2, D1.2 (A), D2.2 (A), J1.1, J3.2, Q1.3 (E), R10.2, U1.1 (GND), U2.1 (GND), U2.4 (V-), UNIT_1.4 (COM/GND), UNIT_1.29 (COM/GND), UNIT_2.6 (GND), VR1.2
High: J4.2, J4.4, UNIT_2.8 (High_CAN)
Low: J4.1, J4.3, UNIT_2.9 (Low_CAN)
unnamed: C1.1, R5.2, R11.1
unnamed: D1.1 (K), D2.1 (K), R1.2, R2.1
unnamed: Q1.2 (B), R2.2
unnamed: R4.1, R7.2
unnamed: R4.2, R6.1
unnamed: C4.1, U1.5 (CV)
unnamed: C3.2, R7.1, U1.6 (THR), U1.7 (DIS)
unnamed: U2.3 (-), VR1.3
Possitive: J1.2, R1.1
SCK: UNIT_1.16 (D13/SCK), UNIT_2.2 (SCK)
SCL: UNIT_1.24 (A5)
SDA: UNIT_1.23 (A4)
SI: UNIT_1.14 (D11/MOSI), UNIT_2.3 (SI)
SO: UNIT_1.15 (D12/MISO), UNIT_2.4 (SO)
arduino input: C2.1, R11.2, UNIT_1.19 (A0)

Notes on the sheet:
CAN Bus
Low
Nano
High
Socket
I/O
GND
Connector Pinout
Nano socketed with HWS16130 http://www.peconnectors.com/sockets-sip-machined/ hws16130/?utm_source=googleads&vt_keyword=&gad_source= 1&gbraid=0AAAAAD-J6wRIeL1mScc81doEXt4u-oFxN&gclid=Cj0KC QiA4rK8BhD7ARIsAFe5LXJCXX4yoeMSgdYYrUZ8CYCOGg6YWjx-KireWWb9vicOqA-PgvhT3uIaAs8kEALw_wcB
+5v
