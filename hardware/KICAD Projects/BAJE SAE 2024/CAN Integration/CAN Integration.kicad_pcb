# Repository UofA-BAJA/2024-2025-Firmware (continued)

## KiCad design hardware/KICAD Projects/BAJE SAE/Sensor Projects/Tachometer/Tachometerkicad.kicad_pcb (continued)

Board: 2 copper layers, 80.0 x 85.0 mm, 24 parts (0 on the bottom side), 21 nets.

## Commit log (part)

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2024-09-07 Working on initial project
2024-09-08 Got basic CMake configuration set up
2024-09-09 More cmake setup
2024-09-09 test
2024-09-09 Even more setup yay
2024-09-09 introduced commands
2024-09-09 A bunch of crazy stuff that I don't like
2024-09-09 added commands to cmake file
2024-09-09 Absolutely cooking on the setup
2024-09-09 Project structure
2024-09-09 Added comments to the commands enum
2024-09-11 Mounting requirements document
2024-09-12 Implemented procedures
2024-09-13 Beginning CAN project
2024-09-14 Working on the procedure scheduler to react to commands
2024-09-14 More procedure work
2024-09-14 Fixed procedure but due to not using iterators
2024-09-14 a lil comment :)
2024-09-14 More documentation/ minor changes
2024-09-14 servo testing - works!
2024-09-15 Coding IMU for CAN testing
2024-09-15 Fixing conflicts
2024-09-16 CANDispatcher created
2024-09-16 pain and suffering
2024-09-16 AAAAA
2024-09-16 Trying to get the multithreading to work
2024-09-16 Can Dispatcher successful
2024-09-17 Writing documentation and cleaning code
2024-09-17 Rearranging files
2024-09-18 Uhh broken things =D
2024-09-19 Added CANopenLinux submodule
2024-09-20 Removed CANopenLinux submodule
2024-09-20 added CANopen-Stack submodule
2024-09-23 Removed CANopen Stack
2024-09-23 lotsa stuff (#5)
    * Rearranging files
    * Uhh broken things =D
    * Added CANopenLinux submodule
    * Made CAN Dispatcher backup
    * Removed CANopenLinux submodule
    * added CANopen-Stack submodule
2024-09-26 i forgor
2024-09-28 literally nothing important
2024-09-28 sqlite 3 testing
2024-09-28 fjhbgrejhg
2024-09-28 fix funny byte drop issue
2024-10-03 Making CAN interface reset in can dispatcher class
2024-10-03 Setting up database stuff
2024-10-08 Make Dash Branch, other tests
2024-10-11 Working on the data store and beginning to work on error handling and logging
2024-10-14 implement CAN, servos
2024-10-17 Lots and lots of performance improvements
2024-10-17 Basic log file implementation
2024-10-19 All the pain and suffering
2024-10-23 CAN works!
2024-10-28 vvvvvvvvvvvvvvvvv bvcvbvc
2024-11-01 Major CAN Dispatcher debugging and bugfixing
2024-11-02 Fixed CAn dispatcher segmentation fault error I think
2024-11-02 imu acceleration worky worky???
2024-11-02 deal with bno055 library
2024-11-04 Fixed another can dispatcher bug
2024-11-04 Create car wiring diagram
2024-11-04 Test 1
2024-11-04 Wiring Diagram Commit
    Completed Functional Wiring Diagram
2024-11-06 Big Commit
    Added functional block diagram, kicad files for power regulator schematic, PCB and BOM, buck converter configurations for 3.3v and 5v, bills of materials for the buck converter configurations
2024-11-06 Updated Power Reg PCB Commit
2024-11-07 Created new Power Regulator design using the LT8606
2024-11-07 Completed LT8606 Schematic
2024-11-07 ESP 32 Dash
2024-11-07 Work on PCB layout
2024-11-07 Worked on tutorial PCB and reorganized doc folder
2024-11-07 created POC of rasberry pi and sensor schematic
2024-11-09 idk what this is tbhhh
2024-11-16 servos YAY
2024-11-18 imu esp32
2024-11-18 First draft of AZ1084C PS completed
2024-11-23 dash work
2024-11-23 UNTESTED no callback sendcan
2024-11-23 Sensor PCB Design work
2024-11-24 Coms work!
2024-11-25 Updated IMU PCB/Uploaded custom symbology
2024-11-25 The temperature goodies
2024-11-25 Working temperature sensor =D
2024-11-25 Updated IMU PCB
2024-11-25 CAN ID filtering
2024-11-26 Starting radio protocols
2024-11-26 Updated IMU PCB and CANbus footprint
    CAN bus footprint was not explicit in facing up or facing down. Updated to be explicit and edited PCB to match.
2024-11-26 Updated symbols and footprints
    Actually updated the symbol libraries this time
2024-11-27 Final Touches on IMU
2024-11-28 Updated ESP-32 IMU PCB
    Added J2 as a bypass for the power regulator
2024-11-29 Reorganized Hardware section, added project template
2024-11-29 Added Template, moved wiring diagrams to hardware
2024-11-29 decapitalized hardware, looked weird
2024-11-30 Actually added the template this time
2024-12-02 Made Temp Sensor PCB
2024-12-02 Removal of hardware files for updated git ignore
2024-12-02 hardware reupload after git ignore update
2024-12-06 COMMMMMMMMMMMMMMS
2024-12-06 Functioning live wireless data omg
2024-12-06 Sorted live data streams when adding them + more com testing
2024-12-07 dash subsystem worked on
2024-12-07 more radio stuff
2024-12-07 inherent cooldown on wrapper library
2024-12-07 Working commands from pit!
2024-12-10 Working wrapper library "cooldown"
2024-12-12 Added unity projects to the gitignore
2024-12-12 Functioning realtime graphs
2024-12-14 messing around with serial stuff in C#
2024-12-14 Documentation
2024-12-14 maybe the dash will work idk
2024-12-14 oh my god i hate my life
2024-12-15 finally fixed the stupidest bug ever. put the correct variable names in the function parameters!
2024-12-17 Corrected onboard labels from IMU to TEMP on temperature sensor
2025-01-06 Added PCB design guide infographic
2025-01-07 Updated IMU PCB to Revision 2
    sectioned off schematic
    changed schematic from wires to flags
    edited PCB to be much smaller
    updated J1 to be correct size
    increased ESP 32 pad size
    updated CAN Bus to hang off board
2025-01-07 Updated IMU Rev 2 Schem
2025-01-07 Created "Micro" IMU concept
    Created a micro IMU board that aggressively overlaps components. 38% smaller than revision 2.
2025-01-10 added folder for 3D models
2025-01-10 fixed issue that causes the whole pcb not to work
2025-01-14 dash works on cant
2025-01-14 haha time
2025-01-14 updates to esp32 IMU
2025-01-15 Updates to IMU and Temp PCB
2025-01-15 Updates to temperature sensor PCB
2025-01-15 Updates to IMU and Temp.
2025-01-18 avoid merge confltc
2025-01-18 haha yes
2025-01-18 Added time class
2025-01-18 finished imu, started others
2025-01-20 dash and temp
2025-01-20 Removed KICAD Symbol Libraries
2025-01-20 work on dash onboard
2025-01-20 re-added symbol library
2025-01-20 Removed again :(
2025-01-20 Removed tach project
2025-01-20 tach updates
2025-01-20 started main computer
2025-01-21 dash indicator lights
2025-01-21 removed
2025-01-21 Gave dylan files
2025-01-21 gave dylan more files
2025-01-21 added tach file
2025-01-21 i think i know how git works now, my bad
2025-01-21 added nano footprint
2025-01-21 dash works correctly now
2025-01-21 dash finally works onboard
2025-01-21 added c113
2025-01-21 Updated tach schematic
2025-01-21 the last struggle
2025-01-23 Schematic cleanup for Main Computer
2025-01-24 Started doing new CAN experiments to make it much easier to write wrapper libraries.
2025-01-25 created imu 32 w/ pcb header connector
2025-01-25 Updated all the other files to work with the new can device
2025-01-25 Added temperature device
2025-01-25 created tachometer platformio project
2025-01-25 aha the dash code is like 90% done!
2025-01-25 habubhabuhaub
2025-01-25 fixed the broken rpm sending
2025-01-27 tach updat :P
2025-01-27 lord have mercy
2025-01-27 bruh
2025-01-27 servos work
2025-01-27 Mildly updated documentation
2025-01-27 documentation start
2025-01-27 testy testy
2025-01-27 Documentation for CANDeivce
2025-01-27 finished pcbs yayyyy
2025-01-27 Tach Update
2025-01-27 Creating copy of Tachometer as base for Speedometer.
2025-01-28 Updated every file to adhere to the namespace
2025-01-28 Deleting unnecessary files
2025-01-29 Fixing the forgotten namespace declarations
2025-01-29 added breakout to dash
2025-01-29 updated footprint for breakout
2025-01-30 Starting to work on converting pointers to references
2025-01-31 All the pointers that can be turned to references are now references, and it seems to work.
2025-02-01 Setting up a test script for the new procedure scheduler
2025-02-01 Everything should be working in the test for the new procedure scheduler
2025-02-02 Edit page settings for Speedometer.
2025-02-02 Add symbol for A3144 Hall Effect sensor, add to exist DT library file.
2025-02-02 Add all symbols and wires for speedometer circuit.
2025-02-02 Add footprint for Hall Effect sensor, and assign all footprints.
2025-02-02 Add mounting holes with footprints to schematic.
2025-02-02 Add net labels to schematic.
2025-02-02 Change NANO footprint and add all net labels.
2025-02-02 Add footprints to PCB Editor.
2025-02-02 Arange parts and add edge cuts around mounting holes.
2025-02-02 Add routing; add GND copper field.
2025-02-03 slutty tachometer
2025-02-03 Add CAN, Change 5V to Power Inut.
2025-02-03 Add power flags; ERC Checked.
2025-02-03 DRC Check, Edit Silkscreen.
2025-02-03 Add final silkscreen and page settings.
2025-02-03 Generate gerber, drill files and place in GerberFiles folder.
2025-02-03 Finish.
2025-02-03 dash <3
2025-02-03 fixed radio and added spedometer procedure
2025-02-03 Change edge cuts.
2025-02-03 Added 3v3 voltage regulation
2025-02-03 made schematic pretty
2025-02-07 Idk it's a start
2025-02-13 Testing markdown documentation
2025-02-13 another test
2025-02-13 Starting the documentation
2025-02-15 Add new Gerber files.
2025-02-15 Add gerber files with drill.
2025-02-15 Zip all gerber files into 2.0
2025-02-15 Add gerber 2.0
2025-02-15 Add Gerber2.0 for Main computer.
2025-02-15 Changed gerber2.0 name.
2025-02-15 Change Gerber2.0
2025-02-15 Changer temp gerber name.
2025-02-17 More documentation
2025-02-17 The beginnings of a fine documentation indeed
2025-02-17 dash updates
2025-02-20 Started documentation for the data storage
2025-02-21 More documentation and a tiny bit of making code prettier
2025-02-22 Updates to dash
2025-02-22 dash traces done
2025-02-24 made project template
2025-02-24 New Gerber files with corrected pins, Vin, and dimensions.
2025-02-24 Gerber 3.0 added.
2025-02-24 dash
2025-02-27 temp sense worky now
2025-02-27 We got raw data parsing working lets goooo
2025-02-28 fixed tach
2025-02-28 We now have data decoding
2025-02-28 Changed the "protocol" of the serial packet transmission for the radio
2025-03-02 I have no idea =D
2025-03-02 erm uh ermmmm uh
2025-03-02 3D scatter plot tests
2025-03-03 GraphV2
2025-03-04 A bunch of small stuff
2025-03-07 Reuploaded the project because I'm dumb and keep forgetting to open it from the right place
2025-03-07 Doing some build stuff
2025-03-08 Distance integral calculation
2025-03-08 no idea
2025-03-22 hardware updates
2025-03-22 Pretty big progress
2025-03-24 something something data storage
2025-03-26 Created Dash Gerbers
2025-03-26 Add all speedometer hall effect sensors and CAD file.
2025-03-27 mdlkfm
2025-03-28 making changes to try to fix all memory errors
2025-03-29 Working on properly shutting things down
2025-03-29 stuff
2025-03-29 Added spedometer DevLib
2025-03-29 Refactoring (#22)
    * erm uh ermmmm uh
    * Distance integral calculation
    * memory issue fixing
    * something something data storage
    * making changes to try to fix all memory errors
    * Working on properly shutting things down
2025-03-31 oh my god so many changes
2025-04-05 many ythings i just wanna sync it up so it's safe in the cloud
2025-04-05 more sync
2025-04-12 dashboard
2025-04-18 Widgets are moving yay
2025-04-19 servo adjust stuff
2025-04-19 Integrated Speed Code with CAN.
2025-04-20 Data parser
2025-04-21 Added tools folder
2025-04-21 i need to sync
2025-04-25 sync
2025-04-28 dash stufffff
2025-04-28 aaaa
2025-04-28 WE FIXED IT
2025-04-29 Create some logging prodecures
2025-04-30 added new terminal GUI
2025-04-30 Removed spedometerprocedure
2025-05-01 dash workness distance
2025-05-01 guthib
2025-05-01 synchronize
2025-05-01 dashness distance
2025-05-01 finally 2 electric boogaloo
2025-05-01 b r u h
2025-05-01 adjust distance and speed
2025-05-01 attempt at RPM logging
2025-05-02 changed car container
2025-05-02 speed logging, rpmlogging, etc
2025-05-02 Fixed some stuff
2025-05-02 Removed stupid stuff in IMUProcedure
2025-05-04 gui updates
2025-08-23 last commit hopefully!
2025-09-06 Wow new projects
    Started work on new SMD temp sensor. Pulled in schematic of nano to bring into temp sensor
2025-12-06 CAN Refactor Part I (#32)
    * delete a bunch of stuff 1
    * delete a bunch of stuff 2 + cmake
    * delete and move a bunch of stuff 3
    * refactor stuff 4
    * what is a wapper?
    * work
2025-12-06 Revert "CAN Refactor Part I (#32)"
    This reverts commit 641dd4efa560e4399783a4c9d68d072ea098d885.
