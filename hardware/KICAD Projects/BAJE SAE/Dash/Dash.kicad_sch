File: hardware/KICAD Projects/BAJE SAE/Dash/Dash.kicad_sch (KiCad schematic)
At the start: 38 parts, among them J1 Conn_01x02, J10 14 Segment (3), J11 14 Segment (4), J2 CAN to outer connector, J3 Conn_01x06, J4 Servo 1 (RPM), J5 Servo 2 (Speed), J6 Button 1, J7 Button 2, J8 14 Segment (1)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

Commit message: made schematic pretty
Connections:
- net GND: now also R2.2, U1.1 (GND)
- net Regulated 3v3: now also U1.28 (VDD)
- net at RV1.3: now also R1.2, R2.1; no longer R2.2
Other:
- moved on the sheet: D1, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D2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

Commit message: dash updates
Parts:
- RV1: value 300 (3v3 tune) -> 1k (3v3 tune)
Changed lines of the file:
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@@
 			)
 		)
-		(property "Value" "300 (3v3 tune)"
+		(property "Value" "1k (3v3 tune)"
 			(at 145.034 80.01 0)
 			(effects
